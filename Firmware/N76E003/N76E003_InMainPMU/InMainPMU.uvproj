# Keil uVision project InMainPMU.uvproj, settings and files
target InMainPMU (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: N76E003_InMain_PM_ +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Code;.\Code\Common;.\Code\N76E003_HW
  group Source
    ./: STARTUP.A51
    ./Code/: I2C_Slave.c main.c UART.c UART.h I2C_Slave.h hw_Config.h
  group Common
    ./Code/Common/: Common.c Delay.c
